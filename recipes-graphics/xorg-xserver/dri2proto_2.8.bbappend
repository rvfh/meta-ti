FILESEXTRAPATHS_prepend := "${THISDIR}/dri2proto-2.8:"

SRC_URI += "file://0001-video-support-for-dri2.patch"

PR = "r1"
